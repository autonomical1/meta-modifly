PACKAGECONFIG:remove = " resolved nss-resolve networkd"