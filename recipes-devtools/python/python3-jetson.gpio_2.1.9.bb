SUMMARY = "Python Jinja2: A small but fast and easy to use stand-alone template engine written in pure python."
HOMEPAGE = "https://pypi.org/project/Jinja2/"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=963ead04a49bf4a1fe8567be3d7c0b63"

SRC_URI[sha256sum] = "9dcdda8f89b66016c7d7e1ecb32ce2e070415b14e3ae8664577ff2e8bdea6f3b"

PYPI_PACKAGE = "Jetson.GPIO"

inherit pypi